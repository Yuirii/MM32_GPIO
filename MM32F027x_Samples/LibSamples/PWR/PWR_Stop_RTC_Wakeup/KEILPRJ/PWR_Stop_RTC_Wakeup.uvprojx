# Keil uVision project PWR_Stop_RTC_Wakeup.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F0273D7P MindMotion
  pack: MindMotion.MM32F0270_DFP.0.0.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F027x\Include;..\..\..\..\..\Device\MM32F027x\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\PWR;..\HARDWARE\LED;..\HARDWARE\TIM;..\HARDWARE\USUALLY;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../Device/MM32F027x/Source/: system_mm32f027x.c
    ../../../../../Device/MM32F027x/Source/KEIL_StartAsm/: startup_mm32f027x_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWR/: pwr.c
    ../HARDWARE/TIM/: tim1_interrupt.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
    ../HARDWARE/USUALLY/: usually.c
    ../HARDWARE/SPI/: spi.c
  group USER
    ../USER/: main.c Handle.c verifypro.c mapping.c
  group HAL_Lib
    ../../../../../Device/MM32F027x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
