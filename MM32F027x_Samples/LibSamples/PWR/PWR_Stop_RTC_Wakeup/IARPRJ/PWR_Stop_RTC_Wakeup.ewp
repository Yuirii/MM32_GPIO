# IAR project PWR_Stop_RTC_Wakeup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0273D8P MindMotion MM32F0273D8P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32F0273D8P; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\MM32F027x\Include; ..\..\..\..\..\Device\MM32F027x\HAL_Lib\Inc; ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\USER; ..\SYSTEM\UART; ..\SYSTEM\SYS; ..\SYSTEM\DELAY; ..\HARDWARE\PWR; ..\HARDWARE\LED; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STARTUP
    ../../../../../Device/MM32F027x/Source/IAR_StartAsm/: startup_mm32f027x_iar.s
    ../../../../../Device/MM32F027x/Source/: system_mm32f027x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWR/: pwr.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../../../../Device/MM32F027x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
